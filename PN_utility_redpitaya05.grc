options:
  parameters:
    generate_options: qt_gui
    id: SdrplayTests
    output_language: python
    title: sdrplay
  states: {}

blocks:
- name: ADC_Clock
  id: variable
  parameters:
    value: 122.88e6
  states: {}
- name: Carrier_corr_dB
  id: variable
  parameters:
    value: '[(-carrier_level_dB) ]*M'
  states: {}
- name: M
  id: variable
  parameters:
    value: N//2
  states: {}
- name: N
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: N_Average
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,3,1,1)
    label: Averages
    label0: '32'
    label1: '64'
    label2: '128'
    label3: '256'
    num_opts: '4'
    option0: '32'
    option1: '64'
    option2: '128'
    option3: '256'
    type: int
    value: '128'
  states: {}
- name: N_Delay
  id: variable_qtgui_chooser
  parameters:
    gui_hint: (0,2,1,1)
    label: Delay
    label0: '1'
    num_opts: '1'
    option0: '1'
    type: int
    value: '1'
  states: {}
- name: N_Delay
  id: variable_qtgui_range
  parameters:
    label: N-Delay
    outputmsgname: value
    rangeType: int
    showports: 'False'
    start: '0'
    step: '1'
    stop: N
    value: N//2
  states: {state: disabled}
- name: T_Delay
  id: variable
  parameters:
    value: (1/samp_rate)*N_Delay
  states: {}
- name: bin_1Hz_corr
  id: variable
  parameters:
    value: 10*math.log10(bin_bw)
  states: {}
- name: bin_bw
  id: variable
  parameters:
    value: fft_bw/n_bins
  states: {}
- name: carrier_level_dB
  id: variable_function_probe
  parameters:
    block_id: probe_carrier_dB
    function_name: level
    poll_rate: '1'
    value: '0'
  states: {}
- name: cl_1hz
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: (0,1,1,1)
    label: Carrier level 1Hz
    'true': '1'
    type: real
    value: '0'
  states: {}
- name: cosx_x_M
  id: variable
  parameters:
    value: ' [math.cos(x*math.pi/(8*M)) *math.cos(x*math.pi/(8*M))   / ((1e-3 +x*math.pi/(2*M)) *(1e-3 +x*math.pi/(2*M)))  for x in range(M) ]'
  states: {}
- name: fft_bw
  id: variable
  parameters:
    value: samp_rate
  states: {}
- name: fp_an_1
  id: variable_function_probe
  parameters:
    block_id: an_10k
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: fp_an_2
  id: variable_function_probe
  parameters:
    block_id: an_20k
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: fp_an_3
  id: variable_function_probe
  parameters:
    block_id: an_50k
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: fp_an_4
  id: variable_function_probe
  parameters:
    block_id: an_100k
    function_name: level
    poll_rate: '2'
    value: '0'
  states: {}
- name: freq
  id: variable
  parameters:
    value: 25e6
  states: {}
- name: n_bins
  id: variable
  parameters:
    value: N
  states: {}
- name: noise_on
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    label: Noise gen on
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: placeholder_1
  id: variable_qtgui_label
  parameters:
    gui_hint: (0,4,1,3)
    label: '" "'
    type: string
    value: '"."'
  states: {}
- name: rx_samp_rate
  id: variable
  parameters:
    value: int(samp_rate)
  states: {}
- name: samp_rate
  id: variable_qtgui_chooser
  parameters:
    label: Sample Rate
    label0: 384k
    label1: 768k
    label2: 1536k
    num_opts: '3'
    option0: '384000'
    option1: '768000'
    option2: '1536000'
    orient: Qt.QHBoxLayout
    type: int
    value: '384000'
  states: {}
- name: sample_rate_2
  id: variable
  parameters:
    value: 1/rx_samp_rate**2
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    gui_hint: (2,2,1,1)
    label: 'Carrier: '
    type: string
    value: '"%3.2f" % carrier_level_dB  + '' dBm'''
  states: {}
- name: variable_qtgui_label_0_0
  id: variable_qtgui_label
  parameters:
    gui_hint: (2,0,1,1)
    label: 'FFT  bw: '
    type: string
    value: '"%3.0f" % bin_bw + '' Hz'''
  states: {}
- name: variable_qtgui_label_0_0_0
  id: variable_qtgui_label
  parameters:
    label: '1 Hz Correction: '
    type: string
    value: '"%2.1f" % bin_1Hz_corr + '' dB'''
  states: {}
- name: variable_qtgui_label_0_0_1
  id: variable_qtgui_label
  parameters:
    label: 'AN 10kHz: '
    type: string
    value: '"%3.2f" % fp_an_1  + '' dB/Hz'''
  states: {}
- name: variable_qtgui_label_0_0_1_0
  id: variable_qtgui_label
  parameters:
    label: 'AN 20kHz: '
    type: string
    value: '"%3.2f" % fp_an_2  + '' dB/Hz'''
  states: {}
- name: variable_qtgui_label_0_0_1_0_0
  id: variable_qtgui_label
  parameters:
    label: 'AN 50kHz: '
    type: string
    value: '"%3.2f" % fp_an_3 + '' dB/Hz'''
  states: {}
- name: variable_qtgui_label_0_0_1_0_1
  id: variable_qtgui_label
  parameters:
    label: 'AN 100kHz: '
    type: string
    value: '"%3.2f" % fp_an_4 + '' dB/Hz'''
  states: {}
- name: variable_qtgui_label_0_1
  id: variable_qtgui_label
  parameters:
    label: T_delay
    type: real
    value: T_Delay
  states: {}
- name: variable_qtgui_label_0_1_0
  id: variable_qtgui_label
  parameters:
    label: f_delay
    type: real
    value: 1/T_Delay
  states: {}
- name: win_pwr_corr
  id: variable
  parameters:
    value: '2.0'
  states: {}
- name: an_100k
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: an_10k
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: an_20k
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: an_50k
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: analog_const_source_x_0_0
  id: analog_const_source_x
  parameters:
    const: bin_bw
    type: float
  states: {}
- name: analog_const_source_x_0_1
  id: analog_const_source_x
  parameters:
    const: bin_bw
    type: float
  states: {}
- name: analog_fastnoise_source_x_1
  id: analog_fastnoise_source_x
  parameters:
    amp: '3.16e-3'
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: Carrier_corr_dB
    type: float
    vlen: M
  states: {}
- name: blocks_argmax_xx_0
  id: blocks_argmax_xx
  parameters:
    num_inputs: '1'
    type: float
    vlen: N
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_1
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_2
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_3
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_divide_xx_1_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: blocks_keep_m_in_n_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: M
    n: N
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: M
    n: N
    offset: '0'
    type: complex
  states: {}
- name: blocks_keep_m_in_n_0_1
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: M
    offset: int(10000//bin_bw)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0_1_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: M
    offset: int(50000//bin_bw)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0_1_0_0
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: M
    offset: int(20000//bin_bw)
    type: float
  states: {}
- name: blocks_keep_m_in_n_0_1_1
  id: blocks_keep_m_in_n
  parameters:
    m: '1'
    n: M
    offset: int(100000//bin_bw)
    type: float
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: N_Average
    max_iter: '4000'
    scale: 1/N_Average
    type: float
    vlen: M
  states: {}
- name: blocks_moving_average_xx_0_0
  id: blocks_moving_average_xx
  parameters:
    length: N_Average
    max_iter: '1000'
    scale: 1/N_Average
    type: float
    vlen: M
  states: {}
- name: blocks_moving_average_xx_0_0_0_0
  id: blocks_moving_average_xx
  parameters:
    length: '16'
    max_iter: '100'
    scale: 1/16
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: cosx_x_M
    type: float
    vlen: M
  states: {}
- name: blocks_multiply_const_xx_0
  id: blocks_multiply_const_xx
  parameters:
    const: (1/N)*win_pwr_corr
    type: complex
  states: {}
- name: blocks_multiply_const_xx_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: (1/N)*win_pwr_corr
    type: float
  states: {}
- name: blocks_multiply_const_xx_0_0_0
  id: blocks_multiply_const_xx
  parameters:
    const: 1e5*1/122.88e6
    type: float
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: 1/(50*2)
    type: float
  states: {}
- name: blocks_multiply_const_xx_2
  id: blocks_multiply_const_xx
  parameters:
    const: int(bin_bw)
    type: short
  states: {state: disabled}
- name: blocks_multiply_const_xx_3
  id: blocks_multiply_const_xx
  parameters:
    const: '1.04'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_4
  id: blocks_multiply_const_xx
  parameters:
    const: 1/(50*2)
    type: float
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
    vlen: M
  states: {}
- name: blocks_nlog10_ff_0_1
  id: blocks_nlog10_ff
  parameters:
    k: '-1'
    n: '10'
    vlen: M
  states: {}
- name: blocks_nlog10_ff_0_1_1
  id: blocks_nlog10_ff
  parameters:
    k: '30'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: short
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: M
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: M
    type: float
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: float
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: M
    type: float
  states: {}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: digital_diff_phasor_cc_0
  id: digital_diff_phasor_cc
  parameters: {}
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.blackmanharris(N)
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'False'
    type: float
    window: window.blackmanharris(N)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    note: GUI
  states: {}
- name: note_1
  id: note
  parameters:
    note: 1Volt peak = 10dBm
  states: {}
- name: note_10_0
  id: note
  parameters:
    note: 'ToDo: noise TX for calibration'
  states: {}
- name: note_10_1
  id: note
  parameters:
    note: 'TBD: Frequency entry'
  states: {}
- name: note_10_2
  id: note
  parameters:
    note: 'TBD: nyquist calibration'
  states: {}
- name: note_11
  id: note
  parameters:
    note: cause phase errors on RX???
  states: {}
- name: note_12
  id: note
  parameters:
    note: '*(sin(x)/x)**2'
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: Max Wert 0.6
  states: {}
- name: note_2
  id: note
  parameters:
    note: Power corr. Blackm. 2.0
  states: {}
- name: note_2_0
  id: note
  parameters:
    note: 'RP16-122.88: 1.04'
  states: {}
- name: note_3
  id: note
  parameters:
    note: P=(Ueff^2)/50Ohm
  states: {}
- name: note_4
  id: note
  parameters:
    note: Differentiate Phase
  states: {}
- name: note_4_0
  id: note
  parameters:
    note: Normalization 1/N
  states: {}
- name: note_5
  id: note
  parameters:
    note: 3.16e3 --> -111.3 dBm/Hz am SA
  states: {}
- name: note_6
  id: note
  parameters:
    note: 'B window: Ampl: *2.8, Power * 1.97'
  states: {}
- name: note_7
  id: note
  parameters: {}
  states: {}
- name: note_7_0
  id: note
  parameters:
    note: P=50Ohm*Ueff^2
  states: {}
- name: note_8
  id: note
  parameters:
    note: ' [math.cos(x*math.pi/(8*M))  / ((1e-3 +x*math.pi/(2*M)) )  for x in range(M) ]'
  states: {}
- name: note_9
  id: note
  parameters: {}
  states: {}
- name: probe_carrier_dB
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    autoscale: 'True'
    graph_type: qtgui.NUM_GRAPH_NONE
    label1: 'Carrier offset:'
    name: '"Status"'
    type: short
    unit1: Hz
    update_time: '1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: 4*N
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: 4*N
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    average: '0.05'
    grid: 'True'
    label1: Amplitude
    label2: Phase
    name: Spectrums
    nconnections: '2'
    update_time: '0.50'
    vlen: M
    x_axis_label: '"frequency offset [kHz]"'
    x_start: '0'
    x_step: samp_rate/(2*M*1000)
    x_units: '"kHz"'
    y_axis_label: '"PSD [dBc/Hz]"'
    y_units: '"dBc'
    ymax: '-80'
    ymin: '-150'
  states: {}
- name: red_pitaya_sink_0
  id: red_pitaya_sink
  parameters:
    addr: 192.168.10.9
    corr: '0'
    freq: freq
    port: '1001'
    ptt: noise_on
    rate: rx_samp_rate
  states: {}
- name: red_pitaya_source_0
  id: red_pitaya_source
  parameters:
    addr: 192.168.10.9
    corr: '0'
    freq: freq
    port: '1001'
    rate: rx_samp_rate
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: RX_Stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: FFT_Out_Stream
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: Carrier_power
  states: {}
- name: virtual_sink_4_0_0
  id: virtual_sink
  parameters:
    stream_id: ANlog
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: RX_Stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: FFT_Out_Stream
  states: {}
- name: virtual_source_1_1
  id: virtual_source
  parameters:
    stream_id: RX_Stream
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: ANlog
  states: {}

connections:
- [analog_const_source_x_0_0, '0', blocks_divide_xx_1_0, '1']
- [analog_const_source_x_0_1, '0', blocks_divide_xx_0, '1']
- [analog_fastnoise_source_x_1, '0', red_pitaya_sink_0, '0']
- [blocks_add_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_add_const_vxx_0, '0', virtual_sink_4_0_0, '0']
- [blocks_argmax_xx_0, '0', blocks_multiply_const_xx_2, '0']
- [blocks_argmax_xx_0, '1', blocks_null_sink_0, '0']
- [blocks_complex_to_arg_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [blocks_complex_to_mag_squared_1, '0', blocks_multiply_const_xx_1, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_argmax_xx_0, '0']
- [blocks_complex_to_mag_squared_2, '0', blocks_multiply_const_xx_4, '0']
- [blocks_complex_to_mag_squared_2, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_squared_3, '0', blocks_multiply_const_xx_0_0, '0']
- [blocks_divide_xx_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_divide_xx_1_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_keep_m_in_n_0_0, '0', blocks_complex_to_mag_squared_3, '0']
- [blocks_keep_m_in_n_0_0_1, '0', blocks_multiply_const_xx_0, '0']
- [blocks_keep_m_in_n_0_1, '0', an_10k, '0']
- [blocks_keep_m_in_n_0_1_0, '0', an_50k, '0']
- [blocks_keep_m_in_n_0_1_0_0, '0', an_20k, '0']
- [blocks_keep_m_in_n_0_1_1, '0', an_100k, '0']
- [blocks_moving_average_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_moving_average_xx_0_0, '0', blocks_nlog10_ff_0_1, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', blocks_nlog10_ff_0_1_1, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_moving_average_xx_0_0_0_0, '0', virtual_sink_2, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_moving_average_xx_0_0, '0']
- [blocks_multiply_const_xx_0, '0', virtual_sink_1, '0']
- [blocks_multiply_const_xx_0_0, '0', blocks_multiply_const_xx_0_0_0, '0']
- [blocks_multiply_const_xx_0_0_0, '0', blocks_divide_xx_1_0, '0']
- [blocks_multiply_const_xx_1, '0', blocks_moving_average_xx_0_0_0_0, '0']
- [blocks_multiply_const_xx_2, '0', qtgui_number_sink_0, '0']
- [blocks_multiply_const_xx_3, '0', blocks_stream_to_vector_1, '0']
- [blocks_multiply_const_xx_3, '0', virtual_sink_0, '0']
- [blocks_multiply_const_xx_4, '0', blocks_divide_xx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_nlog10_ff_0_1, '0', qtgui_vector_sink_f_0, '1']
- [blocks_nlog10_ff_0_1_1, '0', probe_carrier_dB, '0']
- [blocks_stream_to_vector_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_stream_to_vector_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_1, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_xx_3, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_1, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_1_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_1_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_keep_m_in_n_0_1_1, '0']
- [blocks_vector_to_stream_1, '0', blocks_keep_m_in_n_0_0, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_keep_m_in_n_0_0_1, '0']
- [digital_diff_phasor_cc_0, '0', blocks_complex_to_arg_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_1_0, '0']
- [fft_vxx_0_0, '0', blocks_vector_to_stream_1, '0']
- [red_pitaya_source_0, '0', blocks_throttle_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_1, '0']
- [virtual_source_1, '0', blocks_complex_to_mag_squared_2, '0']
- [virtual_source_1_1, '0', digital_diff_phasor_cc_0, '0']
- [virtual_source_3, '0', blocks_vector_to_stream_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.4.0-rc1
